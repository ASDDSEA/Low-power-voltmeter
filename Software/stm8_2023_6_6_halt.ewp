# IAR project stm8_2023_6_6_halt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: VKL144; $PROJ_DIR$; SGM58031
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8_2023_6_6_halt.srec
  ILINK.IlinkOutputFile: stm8_2023_6_6_halt.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group LCD
    VKL144/: vkl144.c VKL144.h
  group main
    ./: main.c main.h
  group SGM58031
    SGM58031/: ADS1115.c ADS1115.h
