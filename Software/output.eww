<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8_2023_6_6_halt.ewp</path>
    </project>
    <batchBuild />
</workspace>
